# Keil uVision project Hello.uvproj, settings and files
target Simulator (MCS-51)
  device: 8XC52 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: HELLO +hex
  AfterMake: ./hex2bin.exe  @H.BIN @H.HEX
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: HELLO.C
  group Instruction
    ./: program.c boolean.c transfer.c logical.c arithmetic.c instruction.c
  group Documentation
    ./: ABSTRACT.TXT
